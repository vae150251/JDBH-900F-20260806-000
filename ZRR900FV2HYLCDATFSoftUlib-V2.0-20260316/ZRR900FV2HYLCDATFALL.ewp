# IAR project ZRR900FV2HYLCDATFALL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403AVGT7_v2 ArteryTek -AT32F403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ATF403AVCT7; LIBRARY_VERSION; USE_STDPERIPH_DRIVER; AT_START_F403A_V1_0
  ICCARM.CCIncludePath2: ; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\CMSIS\CM4\CoreSupport; Libraries\CMSIS\CM4\DeviceSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ZRR900FV2HYLCDATFALL.bin
  ILINK.IlinkOutputFile: ZRR900FV2HYLCDATFALL_flash.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; LIBRARY\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ; LIBRARY\INC\
  OBJCOPY.OOCOutputFile: timtest.srec
  ILINK.IlinkOutputFile: timtest.out
  ILINK.IlinkIcfFile: C:\mytest520\stm32f10x_flash.icf
  group (top)
    ./: Bhjdq.c Drive.c Eep.c EventManage.c Flash.c GlobeDef.c GlobeDef.h Hzk.c lcd_drv.c Lib.c main.c MenuDiplay.C PModbusS.c Rly_lib.c Set.c stm32f10x_it.c Tim.c ZRR900FV2HYLCDATFALL.a
  group CMSIS
    Libraries/CMSIS/CM4/DeviceSupport/startup/iar/: startup_stm32f10x_atf403a.s
    Libraries/CMSIS/CM4/DeviceSupport/: system_stm32f10x.c
